# Keil uVision project SPI_FLASH.uvprojx, settings and files
target SPI_FLASH (6210000::V6.21::ARMCLANG)
  device: STM32U073CBTx STMicroelectronics
  pack: Keil.STM32U0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20009FFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M0+") TZ
  output: SPI_FLASH +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U073xx
  c include: ../Core/Inc;../Components/sfud/inc;../Drivers/STM32U0xx_HAL_Driver/Inc;../Drivers/STM32U0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Application/MDK-ARM
    ./: startup_stm32u073xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c stm32u0xx_it.c stm32u0xx_hal_msp.c spi.c usart.c
    ../Components/sfud/src/: sfud.c sfud_sfdp.c
    ../Components/sfud/port/: sfud_port.c
  group Drivers/STM32U0xx_HAL_Driver
    ../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal_cortex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal.c stm32u0xx_hal_exti.c stm32u0xx_hal_spi.c stm32u0xx_hal_uart.c stm32u0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u0xx.c
software components: CMSIS:CORE 5.6.0
