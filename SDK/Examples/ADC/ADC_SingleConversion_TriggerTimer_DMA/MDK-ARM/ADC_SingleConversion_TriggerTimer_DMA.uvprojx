# Keil uVision project ADC_SingleConversion_TriggerTimer_DMA.uvprojx, settings and files
target ADC_SingleConversion_TriggerTimer_DMA (6210000::V6.21::ARMCLANG)
  device: STM32U073CBTx STMicroelectronics
  pack: Keil.STM32U0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20009FFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M0+") TZ
  output: ADC_SingleConversion_TriggerTimer_DMA +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U073xx
  c include: ../Core/Inc;../Drivers/STM32U0xx_HAL_Driver/Inc;../Drivers/STM32U0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U0xx/Include;../Drivers/CMSIS/Include; ../Drivers/BSP/STM32U0xx_U0C_LITE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xA000
  group Application/MDK-ARM
    ./: startup_stm32u073xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32u0xx_hal_msp.c stm32u0xx_it.c
  group Drivers/STM32U0xx_HAL_Driver
    ../Drivers/STM32U0xx_HAL_Driver/Src/: stm32u0xx_hal.c stm32u0xx_hal_adc.c stm32u0xx_hal_adc_ex.c stm32u0xx_hal_comp.c stm32u0xx_hal_cortex.c stm32u0xx_hal_crc.c stm32u0xx_hal_crc_ex.c stm32u0xx_hal_cryp.c stm32u0xx_hal_cryp_ex.c stm32u0xx_hal_dac.c stm32u0xx_hal_dac_ex.c stm32u0xx_hal_dma.c stm32u0xx_hal_dma_ex.c stm32u0xx_hal_exti.c stm32u0xx_hal_flash.c stm32u0xx_hal_flash_ex.c stm32u0xx_hal_gpio.c stm32u0xx_hal_i2c.c stm32u0xx_hal_i2c_ex.c stm32u0xx_hal_irda.c stm32u0xx_hal_iwdg.c stm32u0xx_hal_lcd.c stm32u0xx_hal_lptim.c stm32u0xx_hal_opamp.c stm32u0xx_hal_opamp_ex.c stm32u0xx_hal_pcd.c stm32u0xx_hal_pcd_ex.c stm32u0xx_hal_pwr.c stm32u0xx_hal_pwr_ex.c stm32u0xx_hal_rcc.c stm32u0xx_hal_rcc_ex.c stm32u0xx_hal_rng.c stm32u0xx_hal_rng_ex.c stm32u0xx_hal_rtc.c stm32u0xx_hal_rtc_ex.c stm32u0xx_hal_smartcard.c stm32u0xx_hal_smartcard_ex.c stm32u0xx_hal_spi.c stm32u0xx_hal_spi_ex.c stm32u0xx_hal_tim.c stm32u0xx_hal_tim_ex.c stm32u0xx_hal_tsc.c stm32u0xx_hal_uart.c stm32u0xx_hal_uart_ex.c stm32u0xx_hal_usart.c stm32u0xx_hal_usart_ex.c stm32u0xx_hal_wwdg.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u0xx.c
  group Drivers/BSP/STM32U0xx_U0C_LITE
    ../Drivers/BSP/STM32U0xx_U0C_LITE/: stm32u0xx_u0c_lite.c
software components: CMSIS:CORE 5.6.0
